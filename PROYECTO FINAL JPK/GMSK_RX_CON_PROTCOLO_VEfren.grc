options:
  parameters:
    generate_options: qt_gui
    id: GMSK
    output_language: python
    title: GMSK_RX
  states: {}

blocks:
- name: BT
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: BT
    start: '0.0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    start: 50E6
    step: '1'
    stop: 220E6
    value: 200e6
    widget: slider
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    start: '0'
    step: '0.01'
    stop: '40'
    value: '31.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Canal
    label1: Rx
    num_tabs: '2'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 2240E6
    fftsize: '1024'
    gui_hint: 3,1,1,1
    label1: BT = 0.3
    name: '"Espectro RX"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: Rx Bits
    name: ''
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'transmited@1: 0,0,1,1'
    label1: Phase I
    label2: Quadrature Q
    name: ''
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,1
    label0: Constelacion Rx
    num_tabs: '1'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: 437e6
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: if_gain
  states: {state: disabled}
- name: transmited
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation Tx
    label1: Envolvente compleja Post Canal
    num_tabs: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: if_gain
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_simple_squelch_cc_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_gmsk_demod_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_gmsk_demod_0, '0', satellites_nrzi_decode_0, '0']
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0, print]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [soapy_hackrf_source_0, '0', analog_agc3_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc3_xx_0, '0']

metadata:
  file_format: 1
